Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: TP200-VO-80X80-H50-SCHARNIER-TRI LOCK-INSULATION 50.IFC
Time: 2019-04-05T11:50:14
Author: com2it
Organization: Hewlett-Packard Company
Written by: SwIFC
Made in: SolidWorks 2015

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: TP200-EX-VO-80-A-H50-SCHARNIER
In: Default Storey
PSet_Mass_Property - Mass Measure: 62.7614; Area Measure: 4.40331 m2; Volume Measure: 0.00805029 m3
